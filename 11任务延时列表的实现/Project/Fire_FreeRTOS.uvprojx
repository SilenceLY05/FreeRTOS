# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Fire_FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\freertos\include;..\freertos\portable\RVDS\ARM_CM3;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c
  group FreeRTOS/Ports
    ../freertos/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS/Source
    ../freertos/include/: list.h FreeRTOSConfig.h portmacro.h FreeRTOS.h portable.h projdefs.h task.h
    ../freertos/: list.c tack.c
  group doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
